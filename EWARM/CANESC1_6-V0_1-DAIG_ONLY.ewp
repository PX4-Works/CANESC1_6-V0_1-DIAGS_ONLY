# IAR project CANESC1_6-V0_1-DAIG_ONLY.ewp, settings and files
configuration CANESC1_6-V0_1-DAIG_ONLY Configuration (ARM, debug)
  General.OGChipSelectEditMenu: STM32F446RE ST STM32F446RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F446xx
  ICCARM.CCIncludePath2: ..\Inc; ..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; ..\Drivers\CMSIS\Include; ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: CANESC1_6-V0_1-DAIG_ONLY Configuration.out
  ILINK.IlinkIcfFile: stm32f446xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f446xx.s startup_stm32f446xx.s startup_stm32f446xx.s
  group Application/User
    ../Src/: esc_test.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c stm32f4xx_it.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c main.c stm32f4xx_hal_msp.c
    ../Inc/: esc_test.h
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_dma.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_dma.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_dma_ex.c
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
