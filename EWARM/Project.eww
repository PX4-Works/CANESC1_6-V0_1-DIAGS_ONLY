<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\CANESC1_6-V0_1-DAIG_ONLY.ewp</path>
  </project>
  <batchBuild />
</workspace>
